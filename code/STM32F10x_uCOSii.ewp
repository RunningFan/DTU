# IAR project STM32F10x_uCOSii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_DEBUG
  ICCARM.CCIncludePath2: Src\APP; Src\BSP; Src\CM3; Src\uCOS-II\Ports; Src\uCOS-II\Src; Src\uCOS-CPU; Src\uCOS-LIB; Src\CPU\inc; Src\CPU\src; Src\DevDriver; Src\Compress; Src\Compress\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ZTS25V24.bin
  ILINK.IlinkOutputFile: ucos_template.out
  ILINK.IlinkIcfFile: \icf\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: src\APP; src\BSP; src; src\CM3; src\CPU\inc; src\DevDriver; src; src\uCOS-CPU; src\uCOS-II\Ports; src\uCOS-II\Src; src\uCOS-LIB; src\Compress\include; src\Compress\lib; src\Compress
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: STM32F10x_uCOSii.srec
  ILINK.IlinkOutputFile: STM32F10x_uCOSii.out
  ILINK.IlinkIcfFile: STM32F10x_uCOSii.icf
  group APP
    src/APP/: app.c app_cfg.h common.h duplicate.c duplicate.h err_handle.c fsm.c fsm.h myscanf.c myscanf.h os_cfg.h real_handle.c real_handle.h statistic.c statistic.h stm32f10x_conf.h takedata.c takedata.h
    src/CM3/: stm32f10x.h
  group BSP
    src/BSP/: bsp.c bsp.h stm32f10x_it.c stm32f10x_it.h
  group CM3
    src/CM3/: core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group Compress
    src/Compress/: adler32.c compress.c Compress.h crc32.c deflate.c trees.c zutil.c
  group CPU/inc
    src/CPU/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CPU/src
    src/CPU/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    src/DevDriver/: drv_button.c drv_button.h drv_can.c drv_can.h drv_flash.c drv_flash.h drv_gprs.c drv_gprs.h drv_led.c drv_led.h drv_net.c drv_net.h drv_rtc.c drv_rtc.h drv_sms.c drv_sms.h drv_timer.c drv_timer.h drv_usart.c drv_usart.h
  group Startup
    src/Startup/: startup_stm32f10x_hd.s
    icf/: stm32f10x_flash.icf
  group uC/CPU
    src/uCOS-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group uC/LIB
    src/uCOS-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II/Ports
    src/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Src
    src/uCOS-II/Src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
