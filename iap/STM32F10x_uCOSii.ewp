# IAR project STM32F10x_uCOSii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_DEBUG
  ICCARM.CCIncludePath2: Src\APP; Src\BSP; Src\CM3; Src\uCOS-II\Ports; Src\uCOS-II\Src; Src\uCOS-CPU; Src\uCOS-LIB; Src\CPU\inc; Src\CPU\src; Src\DevDriver; Src\Compress; Src\Compress\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTU_GPRS_IAP.bin
  ILINK.IlinkOutputFile: ucos_template.out
  ILINK.IlinkIcfFile: \icf\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: STM32F10x_uCOSii.srec
  ILINK.IlinkOutputFile: STM32F10x_uCOSii.out
  group APP
    src/APP/: app.c app_cfg.h common.h iap.c iap.h stm32f10x_conf.h
    src/CM3/: stm32f10x.h
  group BSP
    src/BSP/: bsp.c bsp.h stm32f10x_it.c stm32f10x_it.h
  group CM3
    src/CM3/: core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group Compress
    src/Compress/: adler32.c compress.c Compress.h crc32.c deflate.c trees.c zutil.c
  group CPU/inc
    src/CPU/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CPU/src
    src/CPU/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    src/DevDriver/: drv_button.c drv_button.h drv_flash.c drv_flash.h drv_led.c drv_led.h drv_rtc.c drv_rtc.h drv_timer.c drv_timer.h drv_usart.c drv_usart.h
  group Startup
    src/Startup/: startup_stm32f10x_hd.s
    icf/: stm32f10x_flash.icf
